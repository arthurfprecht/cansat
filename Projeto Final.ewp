# IAR project Projeto Final.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: adc-driver.c gpio-driver.c led-driver.c main.cpp pwm-driver.c timer-driver.c usart-driver.c
  group BMP280
    BMP280/: BMP280-library.cpp
  group Core
    Core/: adc.c adc_f1.c dma.c dma_f1.c exti.c exti_f1.c flash.c gpio.c gpio_f1.c i2c.c i2c_f1.c nvic.c rcc.c rcc_f1.c spi.c spi_f1.c sysInit .c systick.c timer.c usart.c usart_f1.c usart_private.c util.c util_adc.c
  group Core/Vector
    Core/Vector/: cexit.s cmain.s cstartup_M.s cstartup_ropi_M.s cstartup_rwpi_M.s vector_table_M.s vectortrap_M.s vectortrap_M_exit.s XXexit.s
  group MPU6050
    MPU6050/: I2C.c MPU6050.c
  group SPI
    SPI/: SPI.cpp
  group Wire
    Wire/: HardWire.cpp Wire.cpp WireBase.cpp
